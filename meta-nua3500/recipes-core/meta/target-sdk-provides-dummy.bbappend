DUMMYPROVIDES_remove_nvt_common = "busybox-dev perl-dev"
