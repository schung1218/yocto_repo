FILESEXTRAPATHS_prepend_nvt_common := "${THISDIR}/${PN}:"
